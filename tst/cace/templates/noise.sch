** sch_path: tst/cace/templates/noise.sch
**.subckt noise
V0 VSS GND 0
V2 VDD GND CACE{vdd}
Vp Vp GND dc CACE{vcm} ac 1
x1 Vp Vout Vout VDD VSS ota-5t-buf
**** begin user architecture code


.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/sky130.lib.spice CACE{corner}
.include CACE{DUT_path}
.include /foss/designs/Chipathon2024/ota-5t-buf/xschem/sizing_ota-5t-buf.spice
.temp CACE{temperature}




.control
    noise v(Vout) Vp dec 20 1k 100e9
    setplot noise2
    let NOI = onoise_total/1e-6
    echo $&NOI > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end
